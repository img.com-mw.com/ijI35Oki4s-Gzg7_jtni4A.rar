! 1/20/2025 12:57:56 PM
! D:\YHJ\ZDC25-30C0.5-18G-656\1.1.S2P
! CHANNEL.1
! TR.MEASUREMENT
! CORRECTED.DATA
! RF.CORRECTION: FULL.TWO.PORT.CAL.PORT.1.2
! AVERAGING.OFF
! IF.BANDWIDTH: NO.IFBW
! SWEEPTYPE:  FREQ.SWEEP(Linear)
! Reference Plane Port Info
! PORT:  PORT1  PORT2
! DISTANCE:  0  m  0  m
! TIME:  0  s  0  s
! PHASE.OFFSET:  0 °  0 °
! LOSS:  0  dB  0  dB
! REF.LOSS:  0  dB  0  dB
! REF.FREQ:  0  Hz  0  Hz
! Power Info
! POWER:  -10  dBm  -10  dBm
! EFF.POWER:  -10  dBm  -10  dBm
! SOURCE.ATTEN:  0  dB  0  dB
! TEST.ATTEN:  0  dB  0  dB
# GHZ S RI R 50.0
! FREQ.GHZ  S11RE  S11IM  S21RE  S21IM  S12RE  S12IM  S22RE  S22IM
!; PortSelection: Port_12
! Worked out from all points (weakly coupled two-port):
!   1482 points, 10 MHz to 20.01 GHz, reference 50 ohm
!   highest |S21| = -28.38 dB at 2.953 GHz (marker M1); lowest = -63.4 dB at 10 MHz (marker M2)
!   lowest |S11| = -63.8 dB at 2.319 GHz (marker M3), VSWR 1.00, Z = 49.9 - j0.0289 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -62.8 to -14.7 dB; largest |S21 - S12| = 0.0022
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -43.2  -63.4  -60.3  -51.0
! 482.6 MHz  -48.5  -31.4  -31.6  -36.2
! 2.319 GHz  -63.8  -29.5  -29.4  -31.3
! 2.953 GHz  -41.0  -28.4  -28.6  -33.2
! 3.345 GHz  -40.7  -29.4  -29.5  -35.1
! 3.736 GHz  -37.2  -29.1  -29.1  -48.1
! 6.68 GHz  -42.0  -29.6  -29.6  -24.8
! 7.017 GHz  -31.1  -29.4  -29.6  -54.8
! 7.571 GHz  -43.0  -29.1  -29.1  -21.2
! 10.01 GHz  -32.2  -29.7  -29.6  -22.2
! 13.35 GHz  -31.4  -29.4  -29.5  -25.4
! 14.59 GHz  -24.0  -29.4  -29.7  -20.4
! 15.15 GHz  -34.4  -28.8  -28.8  -48.6
! 15.56 GHz  -21.9  -29.3  -29.3  -24.0
! 16.09 GHz  -38.1  -29.0  -28.9  -32.4
! 16.68 GHz  -24.2  -29.4  -29.3  -28.3
! 17.85 GHz  -37.9  -29.1  -29.2  -27.8
! 18.32 GHz  -26.9  -29.0  -29.0  -19.0
! 18.67 GHz  -45.7  -29.0  -28.9  -25.1
! 19.07 GHz  -27.5  -34.6  -34.4  -18.1
! 19.4 GHz  -59.2  -38.7  -38.1  -15.4
! 20.01 GHz  -26.2  -30.4  -30.4  -15.6
