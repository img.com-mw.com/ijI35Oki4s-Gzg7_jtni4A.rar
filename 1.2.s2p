! 1/20/2025 12:58:39 PM
! D:\YHJ\ZDC25-30C0.5-18G-656\1.2.S2P
! CHANNEL.1
! TR.MEASUREMENT
! CORRECTED.DATA
! RF.CORRECTION: FULL.TWO.PORT.CAL.PORT.1.2
! AVERAGING.OFF
! IF.BANDWIDTH: NO.IFBW
! SWEEPTYPE:  FREQ.SWEEP(Linear)
! Reference Plane Port Info
! PORT:  PORT1  PORT2
! DISTANCE:  0  m  0  m
! TIME:  0  s  0  s
! PHASE.OFFSET:  0 °  0 °
! LOSS:  0  dB  0  dB
! REF.LOSS:  0  dB  0  dB
! REF.FREQ:  0  Hz  0  Hz
! Power Info
! POWER:  -10  dBm  -10  dBm
! EFF.POWER:  -10  dBm  -10  dBm
! SOURCE.ATTEN:  0  dB  0  dB
! TEST.ATTEN:  0  dB  0  dB
# GHZ S RI R 50.0
! FREQ.GHZ  S11RE  S11IM  S21RE  S21IM  S12RE  S12IM  S22RE  S22IM
!; PortSelection: Port_12
! Worked out from all points (weakly coupled two-port):
!   1482 points, 10 MHz to 20.01 GHz, reference 50 ohm
!   highest |S21| = -41.45 dB at 19.02 GHz (marker M1); lowest = -91.0 dB at 131.5 MHz (marker M2)
!   lowest |S11| = -64.6 dB at 1.441 GHz (marker M3), VSWR 1.00, Z = 49.9 + j0.0113 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -57.3 to -14.9 dB; largest |S21 - S12| = 0.0017
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -43.3  -77.6  -69.1  -49.6
! 131.5 MHz  -41.3  -91.0  -64.4  -39.9
! 1.441 GHz  -64.6  -65.4  -65.0  -30.8
! 3.345 GHz  -41.5  -55.6  -58.3  -35.5
! 3.75 GHz  -35.7  -61.1  -59.7  -47.6
! 4.884 GHz  -35.3  -72.7  -64.6  -29.8
! 6.68 GHz  -35.2  -51.3  -51.0  -25.1
! 7.017 GHz  -32.3  -59.7  -59.0  -55.9
! 7.557 GHz  -34.7  -52.2  -53.3  -21.4
! 10.01 GHz  -32.8  -50.0  -49.2  -22.4
! 11.08 GHz  -35.6  -45.6  -46.4  -35.7
! 11.53 GHz  -26.4  -62.3  -63.7  -17.3
! 11.82 GHz  -52.0  -47.0  -46.5  -19.0
! 12.15 GHz  -26.0  -45.0  -44.7  -44.3
! 12.65 GHz  -54.5  -52.6  -53.6  -19.7
! 13.35 GHz  -30.8  -46.2  -46.3  -25.7
! 14.52 GHz  -26.0  -65.6  -62.7  -20.2
! 15.13 GHz  -36.1  -51.7  -50.5  -45.9
! 15.56 GHz  -21.6  -49.8  -49.0  -24.2
! 16.68 GHz  -24.9  -46.8  -46.5  -28.5
! 19.02 GHz  -24.6  -41.5  -42.2  -19.6
! 20.01 GHz  -26.2  -46.1  -47.1  -15.8
